## boards/shields/eyeslash_dongle_config/Kconfig.defconfig
```kconfig
if SHIELD_EYESLASH_DONGLE_CONFIG

if ZMK_DISPLAY

config I2C
    default y

config SSD1306
    default y

endif

endif
```
